# IAR project 6lbr-demo.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: VP_CONFIG_H="contiki-conf.h"; VP_NASSERT; MODEL_CC2530_DK; PROJECT_CONF_H; UIP_CONF_IPV6=1; IAR_FOR_2530
  ICC8051.CCDiagSuppress: pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.PreInclude: cpu\cc253x\8051def.h
  ICC8051.CCIncludePath2: $TOOLKIT_DIR$\INC\DLIB\C; ; core\; core\cfs\; core\ctk\; examples\6lbr-demo\; examples\6lbr-demo\apps\coap; apps\erbium\; apps\er-coap-13\; core\dev\; core\lib\; core\loader\; core\net\; core\net\mac\; core\net\rime\; core\net\ipv6\; core\net\ip\; core\sys\; cpu\; cpu\cc253x\; cpu\cc253x\dev\; platform\; platform\cc2530dk\; platform\cc2530dk\dev\
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
configuration iSmartLight (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: VP_CONFIG_H="contiki-conf.h"; VP_NASSERT; jMODEL_CC2530_ISMART_IRMOTE; MODEL_CC2530_DK; UART1_CONF_ENABLE; UART1_ALTERNATIVE_1; UART1_CONF_WITH_INPUT=1; UART_ONE_CONF_WITH_INPUT=1
  ICC8051.CCIncludePath2: $TOOLKIT_DIR$\INC\DLIB\C\; apps\core\lib; apps\core\rmesh; \apps\core\protocol; ; core\; core\cfs\; core\ctk\; core\dev\; core\lib\; core\loader\; core\net\; core\net\mac\; core\net\rime\; core\net\routing\; core\sys\; cpu\; cpu\cc253x\; cpu\cc253x\dev\; platform\; platform\cc2530dk\; platform\cc2530dk\dev\
  group apps/er-coap-13
    apps/er-coap-13/: er-coap-13-communication.h er-coap-13-engine.c er-coap-13-engine.h er-coap-13-observing.c er-coap-13-observing.h er-coap-13-separate.c er-coap-13-separate.h er-coap-13-transactions.c er-coap-13-transactions.h er-coap-13-udp.c er-coap-13-udp.h er-coap-13.c er-coap-13.h
  group apps/erbium
    apps/erbium/: erbium.c erbium.h
  group core
    core/: contiki-default-conf.h contiki-lib.h contiki-net.h contiki-version.h contiki.h
  group core/dev
    core/dev/: leds.c leds.h radio.h serial-line.c serial-line.h slip.c slip.h watchdog.h
  group core/lib
    core/lib/: assert.c assert.h crc16.c crc16.h gcr.c gcr.h ifft.c ifft.h list.c list.h me.c me.h me_tabs.c me_tabs.h memb.c memb.h mmem.c mmem.h petsciiconv.c petsciiconv.h print-stats.c print-stats.h random.c random.h ringbuf.c ringbuf.h sensors.c sensors.h settings.c settings.h trickle-timer.c trickle-timer.h
    core/lib/strncasecmp/: strncasecmp.c
  group core/net
    core/net/: linkaddr.c linkaddr.h nbr-table.c nbr-table.h netstack.c netstack.h packetbuf.c packetbuf.h packetqueue.c packetqueue.h queuebuf.c queuebuf.h
  group core/net/ip
    core/net/ip/: dhcpc.c dhcpc.h psock.c psock.h resolv.c resolv.h simple-udp.c simple-udp.h slipdev.c slipdev.h tcp-socket.c tcp-socket.h tcpip.c tcpip.h udp-socket.c udp-socket.h uip-debug.c uip-debug.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c uip-udp-packet.h uip.h uip_arch.h uiplib.c uiplib.h uipopt.h
  group core/net/ipv6
    core/net/ipv6/: sicslowpan.c sicslowpan.h uip-ds6-nbr.c uip-ds6-nbr.h uip-ds6-route.c uip-ds6-route.h uip-ds6.c uip-ds6.h uip-icmp6.c uip-icmp6.h uip-nd6.c uip-nd6.h uip6.c
  group core/net/mac
    core/net/mac/contikimac/: contikimac.c contikimac.h
    core/net/mac/: csma.c csma.h frame802154.c frame802154.h framer-802154.c framer-802154.h framer-nullmac.c framer-nullmac.h framer.h mac-sequence.c mac-sequence.h mac.c mac.h nullmac.c nullmac.h nullrdc-noframer.c nullrdc-noframer.h nullrdc.c nullrdc.h phase.c phase.h rdc.h
    core/net/mac/sicslowmac/: sicslowmac.c sicslowmac.h
  group core/net/rime
    core/net/rime/: abc.c abc.h announcement.c announcement.h broadcast-announcement.c broadcast-announcement.h broadcast.c broadcast.h chameleon-bitopt.c chameleon-bitopt.h chameleon-raw.c chameleon-raw.h chameleon.c chameleon.h channel.c channel.h collect-link-estimate.c collect-link-estimate.h collect-neighbor.c collect-neighbor.h collect.c collect.h ipolite.c ipolite.h mesh.c mesh.h multihop.c multihop.h neighbor-discovery.c neighbor-discovery.h netflood.c netflood.h polite-announcement.c polite-announcement.h polite.c polite.h rime.c rime.h rimestats.c rimestats.h rmh.c rmh.h route-discovery.c route-discovery.h route.c route.h rucb.c rucb.h rudolph0.c rudolph0.h rudolph1.c rudolph1.h rudolph2.c rudolph2.h runicast.c runicast.h stbroadcast.c stbroadcast.h stunicast.c stunicast.h timesynch.c timesynch.h trickle.c trickle.h unicast.c unicast.h
  group core/net/rpl
    core/net/rpl/: rpl-conf.h rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-private.h rpl-timers.c rpl.c rpl.h
  group core/sys
    core/sys/: arg.c arg.h autostart.c autostart.h cc.h clock.h compower.c compower.h ctimer.c ctimer.h dsc.h energest.c energest.h etimer.c etimer.h lc-addrlabels.h lc-switch.h lc.h loader.h log.h mt.c mt.h node-id.h process.c process.h procinit.c procinit.h pt-sem.h pt.h rtimer.c rtimer.h stimer.c stimer.h subprocess.h timer.c timer.h
  group cpu/cc253x
    cpu/cc253x/: 8051def.h cc253x.h mtarch.h rtimer-arch.c rtimer-arch.h sfr-bits.h soc.c soc.h
  group cpu/cc253x/dev
    cpu/cc253x/dev/: cc2530-rf.c cc2530-rf.h clock-isr.h clock.c dma.c dma.h dma_intr.c lpm.h port.h port2-intr.c port2.c port2.h uart-intr.c uart.h uart0.c uart0.h uart1.c uart1.h watchdog.c
  group example/6lbr-demo
    examples/6lbr-demo/: 6lbr-demo-main.c 6lbr-demo.c project-conf.h
    examples/6lbr-demo/apps/coap/: er-example-server.c
  group platform/cc2530dk
    platform/cc2530dk/: contiki-conf.h contiki-main.c debug.c debug.h models.h putchar.c viztool.c
  group platform/cc2530dk/dev
    platform/cc2530dk/dev/: adc-sensor.c adc-sensor.h leds-arch.c leds-arch.h slip-arch.c smartrf-sensors.c
